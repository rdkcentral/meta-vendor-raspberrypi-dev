CFLAGS  += " -DEGL_LIB_NAME=libEGL.so.1 -DGLES1_LIB_NAME=libGLESv1_CM.so -DGLES2_LIB_NAME=libGLESv2.so.2 "
