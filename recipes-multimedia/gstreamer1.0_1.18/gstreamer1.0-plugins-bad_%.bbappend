#This is a workaround since hls is already removed
EXTRA_OEMESON:append = " -Dhls=enabled"
